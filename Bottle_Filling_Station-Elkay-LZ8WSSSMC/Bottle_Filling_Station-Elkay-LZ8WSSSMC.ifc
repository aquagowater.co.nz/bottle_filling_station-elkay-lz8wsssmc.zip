Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 346149d2-9753-4a30-9b11-b055fdbb7c8f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Bottle Filling Station-Elkay-LZ8WSSSMC.ifc
Time: 2024-08-02T12:08:53
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 429138; RefLongitude: -71, -3, -24, -373168; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: Bottle Filling Station-Elkay-LZ8WSSSMC:LZ8WSSSMC(Refrigerated Surface Mount Bottle Filling Station Filtered 8GPH Stainless Steel), Bottle Filling Station-Elkay-LZ8WSSSMC:LZ8WSSSMC(Refrigerated Surface Mount Bottle Filling Station Filtered 8GPH Stainless Steel):765278
In: Level 1
Type - Classification: D2010810 Uniformat (Uniformat); Material: Finish-Elkay-Plastic-1, Finish-Elkay-Steel, Finish-Elkay-Black, Finish-Elkay-Green(1), Finish-Elkay-Red, Finish-Elkay-Yellow, Finish-Elkay-Green
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Elkay Manufacturer Company
Pset_DistributionFlowElementCommon - Reference: LZ8WSSSMC(Refrigerated Surface Mount Bottle Filling Station Filtered 8GPH Stainless Steel); sets with these values: 2
